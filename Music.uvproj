# Keil uVision project Music.uvproj, settings and files
target Target 1 (MCS-51)
  device: P87C51RD2 Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: Music +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c readme.txt
